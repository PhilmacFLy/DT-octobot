# Keil uVision project balancebot.uvproj, settings and files
target Target 1 (166/167)
  device: XE167F-96F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE0FFFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xCBFFFF) CLOCK(20000000) MOD167 MODV2
  output: balancebot
  group Dave Files
    ./: Start_V3.A66 MAIN.C SCS.C IO.C CCU60.C GPT1.C GPT2.C ADC0.C
  group User Files
    ./: motor.c megatron.c sensoric.c balance.c
